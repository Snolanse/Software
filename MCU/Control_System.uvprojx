# Keil uVision project Control_System.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKE02Z64VQH4 NXP
  pack: NXP.MKE02Z4_DFP.10.0.0
  cpu: IRAM(0x1ffffc00,0x1000) IROM(0x00000000,0x010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Control_System
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group Source Group 1
    ./: clock_config.h clock_config.c main.c
software components: CMSIS:CORE 5.0.2, Device:SDK Drivers:adc 2.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.0.0, Device:SDK Drivers:ftm 2.0.2, Device:SDK Drivers:gpio 2.0.0, Device:SDK Drivers:port 2.0.0, Device:SDK Drivers:uart 2.1.5, Device:Startup 1.0.0
